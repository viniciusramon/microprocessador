# Keil uVision project Display LCD, Teclado e LED's.uvprojx, settings and files
target Display LCD, Teclado e LED's (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Display LCD, Teclado e LED's
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Display LCD, Teclado e LED's
    ./: Display LCD, Teclado e LED's.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
